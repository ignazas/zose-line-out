# Repository ignazas/zose-line-out

## KiCad design CS4390.kicad_pcb

Parts:
C1, C2: 0.1uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C3: 10uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C4, C5, C6, C7: 1nF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C8, C9, C10, C11: 220pF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C12, C13: 47uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C15, C16: 1uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C18, C19, C20, C21: 220uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1, D2, D3, D4: D; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
FL1, FL2, FL3, FL4: EMI_Filter_LCL; LED_Rectangular_W5.0mm_H2.0mm-3pins
J1, J2: GS3
J3: Data In; Pin_Header_Straight_1x04_Pitch2.54mm
J4: Power In; Pin_Header_Straight_1x04_Pitch2.54mm
J5: Left; Molex_SPOX-5267_22-03-5035_03x2.54mm_Straight
J6: Right; Molex_SPOX-5267_22-03-5035_03x2.54mm_Straight
R1: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R2, R3, R4, R5, R6, R7, R8: 13.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R9: 13.7kR; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R10, R12, R13: 3.32k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R11: 3,32k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R14, R15, R16, R17: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: OPA2604; DIP-8_W7.62mm_LongPads
U2: CS4390; DIP-20_W7.62mm_LongPads
U3, U4: DRV134; DIP-8_W7.62mm_Socket_LongPads

Connections:
+5V: C2.1, C3.1, J4.2, R1.2, U2.3 (VA), U2.6 (VD)
+15V: C1.1, C16.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J4.1, U1.8 (V+), U3.6 (V+), U4.6 (V+)
BCLK: J3.3, U2.9 (BCLK)
CTRL: J1.1 (G1), J2.1 (G1), R1.1, U2.1 (DEM0), U2.2 (DEM1), U2.11 (~AUTO_MUTE), U2.12 (DIF2), U2.15 (~MUTE_R), U2.16 (~MUTE_L)
GNDA: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C11.2, C15.1, C16.1, FL1.2, FL2.2, FL3.2, FL4.2, J1.3 (G3), J2.3 (G3), J4.3, J5.2, J6.2, R7.2, R9.2, R14.2, R15.1, R16.2, R17.1, U2.4 (AGND), U2.5 (DGND), U3.3 (-), U4.3 (-)
L+: C4.1, R3.1, R7.1, R11.1
L-: C6.1, R2.1, R6.2, R10.1
LRCK: J3.1, U2.7 (LRCK)
MCLK: J3.2, U2.8 (MCLK)
unnamed: C8.2, R10.2, U1.2 (-)
unnamed: C9.1, R11.2, U1.3 (+)
unnamed: C10.1, C13.1, R8.1, U1.7
unnamed: C10.2, R12.2, U1.6 (-)
unnamed: C11.1, R13.2, U1.5 (+)
unnamed: C8.1, C12.1, R6.1, U1.1
unnamed: C12.2, U3.4 (+)
unnamed: C13.2, U4.4 (+)
unnamed: C18.1, U3.7, U3.8
unnamed: C18.2, D3.2 (A), FL1.1, R14.1
unnamed: C19.1, U3.1, U3.2
unnamed: C19.2, D1.2 (A), FL2.1, R15.2
unnamed: C20.1, U4.7, U4.8
unnamed: C20.2, D4.2 (A), FL3.1, R16.1
unnamed: C21.1, U4.1, U4.2
unnamed: C21.2, D2.2 (A), FL4.1, R17.2
unnamed: FL1.3, J5.1
unnamed: FL2.3, J5.3
unnamed: FL3.3, J6.1
unnamed: FL4.3, J6.3
unnamed: J1.2 (G2), U2.20 (DIF0)
unnamed: J2.2 (G2), U2.19 (DIF1)
unnamed: R2.2, U2.17 (AoutL-)
unnamed: R3.2, U2.18 (AoutL+)
unnamed: R4.2, U2.13 (AoutR-)
unnamed: R5.2, U2.14 (AoutR+)
R+: C5.1, R5.1, R9.1, R13.1
R-: C7.1, R4.1, R8.2, R12.1
SDATA: J3.4, U2.10 (SDATA)

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
Board: 2 copper layers, 97.2 x 51.4 mm, 54 parts (0 on the bottom side), 39 nets.

## Commit log

2018-03-19 Version 2
2018-03-19 ground plane
2018-03-26 pre-trace
2018-03-27 base placement
2018-03-28 gerber
2018-03-28 retrace
2018-03-29 ready for prod
2018-03-30 files
2018-03-30 seed studio correction
2018-04-02 Rev B
2018-04-03 zip ignore
